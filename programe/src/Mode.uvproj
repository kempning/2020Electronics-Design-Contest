# Keil uVision project Mode.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SPI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Program/: 282838p.c
    ./: TFT.c
